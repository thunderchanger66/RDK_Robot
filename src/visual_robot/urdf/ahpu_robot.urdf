Commit message: TESTyolo

File: src/visual_robot/urdf/ahpu_robot.urdf (robot description, URDF)
Before this commit: robot four_wheel_robot, 6 links, 5 joints
Links:
- removed link laser
- added link laser_link; visual cylinder length=0.1 radius=0.05
